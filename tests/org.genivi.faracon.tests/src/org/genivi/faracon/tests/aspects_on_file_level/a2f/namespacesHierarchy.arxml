<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 http://autosar.org/schema/r4.0/autosar40/atls">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="350e25a3-df49-4771-9df1-80cc8badd34e">
      <SHORT-NAME>a1</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="b2ddaed4-8cb6-4960-889d-c3fe08bbc2db">
          <SHORT-NAME>b2</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="1c57496d-67e2-49ab-a8b3-c63d7780dcbe">
              <SHORT-NAME>c3</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
